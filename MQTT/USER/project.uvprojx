# Keil uVision project project.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\DHT11;..\HARDWARE\I2C;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\PWM_OC;..\HARDWARE\MOTOR;..\HARDWARE\PWM_IC;..\HARDWARE\INFRARED;..\HARDWARE\MQTT;..\HARDWARE\ESP8266;..\HARDWARE\RJ45_NT1;..\HARDWARE\KEYBOARD;..\HARDWARE\SPI;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\USER;..\HARDWARE\W25Q
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c GUI.c test.c
  group sys
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/dma/: dma.c
  group hardware
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/I2C/: i2c.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/PWM_OC/: pwm.c
    ../HARDWARE/PWM_IC/: pwm_ic.c
    ../HARDWARE/INFRARED/: infrared.c
    ../HARDWARE/MQTT/: mqtt.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/RJ45_NT1/: rj45_nt1.c
    ../HARDWARE/KEYBOARD/: keyboard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/W25Q/: w25q.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:I2C 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
